# Keil uVision project TempSTdPer.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TempSTdPer
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CMSIS\Device\ST\STM32F4xx\Source;.\CMSIS\Device\ST\STM32F4xx\Include;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.7.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c system_stm32f4xx.c.txt
  group StdPeriph
    ./STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_exti.c
    ./: stm32f4xx_syscfg.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 2.6.2
